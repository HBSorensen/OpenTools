# Friendly hostname for the appliance.
hostname = "opentools"
